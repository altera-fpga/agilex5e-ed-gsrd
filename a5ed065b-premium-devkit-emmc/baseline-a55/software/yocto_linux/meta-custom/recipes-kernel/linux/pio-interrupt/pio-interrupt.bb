SUMMARY = "PIO GPIO interrupt driver example"
DESCRIPTION = "A kernel module demonstrating GPIO interrupt handling for FPGA PIO interfaces. This driver registers interrupt handlers for GPIO-based buttons and DIP switches."

LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=12f884d2ae1ff87c09e5b7ccc2c4ca7e"

inherit module

SRC_URI = "file://Makefile \
           file://gpio_interrupt.c \
           file://COPYING \
          "

S = "${WORKDIR}"

# The inherit of module.bbclass will automatically name module packages with
# "kernel-module-" prefix as required by the oe-core build environment.

RPROVIDES:${PN} += "kernel-module-gpio-interrupt"
